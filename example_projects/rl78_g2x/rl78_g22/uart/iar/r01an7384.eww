<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an7384.ewp</path>
    </project>
    <batchBuild />
</workspace>
