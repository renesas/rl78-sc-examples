<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an6640-rl78g22-adc.ewp</path>
    </project>
    <batchBuild />
</workspace>
