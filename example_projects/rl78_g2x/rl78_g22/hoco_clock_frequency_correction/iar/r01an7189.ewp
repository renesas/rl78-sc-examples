# IAR project r01an7189.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F102GGE RL78 - R7F102GGE
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\smc_gen\Config_ELC; src\smc_gen\Config_INTC; src\smc_gen\Config_ITL000_ITL001; src\smc_gen\Config_PCLBUZ0; src\smc_gen\Config_PORT; src\smc_gen\Config_TAU0_0; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg
  ARL78.AsmIncludePath: src\smc_gen\r_config
  OBJCOPY.OOCOutputFile: r01an7189.srec
  ILINK.IlinkOutputFile: r01an7189.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  OBJCOPY.OOCOutputFile: templproj.srec
  group (top)
    ./: buildinfo.ipcf main.c
  group Renesas_SC/smc_gen/Config_ELC
    src/smc_gen/Config_ELC/: Config_ELC.c Config_ELC.h Config_ELC_user.c
  group Renesas_SC/smc_gen/Config_INTC
    src/smc_gen/Config_INTC/: Config_INTC.c Config_INTC.h Config_INTC_user.c
  group Renesas_SC/smc_gen/Config_ITL000_ITL001
    src/smc_gen/Config_ITL000_ITL001/: Config_ITL000_ITL001.c Config_ITL000_ITL001.h Config_ITL000_ITL001_user.c
  group Renesas_SC/smc_gen/Config_PCLBUZ0
    src/smc_gen/Config_PCLBUZ0/: Config_PCLBUZ0.c Config_PCLBUZ0.h Config_PCLBUZ0_user.c
  group Renesas_SC/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_SC/smc_gen/Config_TAU0_0
    src/smc_gen/Config_TAU0_0/: Config_TAU0_0.c Config_TAU0_0.h Config_TAU0_0_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_elc.h r_cg_intc.h r_cg_itl.h r_cg_itl_common.c r_cg_itl_common.h r_cg_itl_common_user.c r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_pclbuz.h r_cg_port.h r_cg_systeminit.c r_cg_tau.h r_cg_tau_common.c r_cg_tau_common.h r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_g22
    src/smc_gen/r_bsp/board/generic_rl78_g22/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_config_reference_ccrl.inc r_bsp_config_reference_iccrl.inc r_bsp_config_reference_llvm.inc r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0162-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0162-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s fsp_common_api.h r_bsp_common.c r_bsp_common.h r_bsp_common_iar.asm r_bsp_rl78_compiler.h r_fsp_error.h r_rtos.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g22
    src/smc_gen/r_bsp/mcu/rl78_g22/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g22/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g22/register_access/iccrl/: intrinsics.h iodefine.h iodefine_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config.inc
  group Renesas_SC/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
