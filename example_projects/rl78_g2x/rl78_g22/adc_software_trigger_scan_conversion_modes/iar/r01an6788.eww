<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an6788.ewp</path>
    </project>
    <batchBuild/>
</workspace>