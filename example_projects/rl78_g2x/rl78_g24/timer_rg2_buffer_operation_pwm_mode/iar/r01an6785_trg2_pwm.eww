<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an6785_trg2_pwm.ewp</path>
    </project>
    <batchBuild />
</workspace>
