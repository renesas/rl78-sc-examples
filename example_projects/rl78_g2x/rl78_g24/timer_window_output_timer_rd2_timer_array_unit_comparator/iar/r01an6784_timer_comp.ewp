# IAR project r01an6784_timer_comp.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F101GLG RL78 - R7F101GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\smc_gen\Config_COMP1; src\smc_gen\Config_DAC1; src\smc_gen\Config_TAU0_0; src\smc_gen\Config_TRD0; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_bsp\mcu\rl78_g24\register_access\iccrl; src\smc_gen\r_pincfg
  ARL78.AsmIncludePath: src\smc_gen\r_config
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: r01an6784_timer_comp.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: src\smc_gen\Config_COMP1; src\smc_gen\Config_DAC1; src\smc_gen\Config_TAU0_0; src\smc_gen\Config_TRD0; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\Config_TRD1; src\smc_gen\r_pincfg
  group (top)
    src/: main.c
    ./: r01an6784_timer_comp.ipcf
  group Renesas_SC/smc_gen/Config_COMP1
    src/smc_gen/Config_COMP1/: Config_COMP1.c Config_COMP1.h Config_COMP1_user.c
  group Renesas_SC/smc_gen/Config_DAC1
    src/smc_gen/Config_DAC1/: Config_DAC1.c Config_DAC1.h Config_DAC1_user.c
  group Renesas_SC/smc_gen/Config_TAU0_0
    src/smc_gen/Config_TAU0_0/: Config_TAU0_0.c Config_TAU0_0.h Config_TAU0_0_user.c
  group Renesas_SC/smc_gen/Config_TRD0
    src/smc_gen/Config_TRD0/: Config_TRD0.c Config_TRD0.h Config_TRD0_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_da.h r_cg_da_common.c r_cg_da_common.h r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_pgacomp.h r_cg_pgacomp_common.c r_cg_pgacomp_common.h r_cg_systeminit.c r_cg_tau.h r_cg_tau_common.c r_cg_tau_common.h r_cg_trd.h r_cg_trd_common.c r_cg_trd_common.h r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_g24
    src/smc_gen/r_bsp/board/generic_rl78_g24/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_config_reference_ccrl.inc r_bsp_config_reference_iccrl.inc r_bsp_config_reference_llvm.inc r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0160-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0160-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s fsp_common_api.h r_bsp_common.c r_bsp_common.h r_bsp_common_iar.asm r_bsp_rl78_compiler.h r_fsp_error.h r_rtos.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g24
    src/smc_gen/r_bsp/mcu/rl78_g24/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g24/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g24/register_access/iccrl/: intrinsics.h iodefine.h iodefine_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config.inc
  group Renesas_SC/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.h
