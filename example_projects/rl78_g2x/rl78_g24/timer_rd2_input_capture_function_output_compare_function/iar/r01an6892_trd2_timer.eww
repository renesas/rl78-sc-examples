<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an6892_trd2_timer.ewp</path>
    </project>
    <batchBuild/>
</workspace>