<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an6973_adc_advanced_mode_simultaneous_sampling.ewp</path>
    </project>
    <batchBuild/>
</workspace>