<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an6786_trg2_phase_counting.ewp</path>
    </project>
    <batchBuild />
</workspace>
