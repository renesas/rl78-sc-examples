<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an5870-rl78g23-tau.ewp</path>
    </project>
    <batchBuild />
</workspace>
