<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an5564-rl78g23-timer.ewp</path>
    </project>
    <batchBuild/>
</workspace>