# IAR project r01an5648-rl78g23-cmp.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R7F100GLG RL78 - R7F100GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: $PROJ_DIR$; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\Config_COMP0; src\smc_gen\Config_COMP1; src\smc_gen\Config_PORT; src\smc_gen\Config_DAC0
  OBJCOPY.OOCOutputFile: r01an5648-rl78g23-cmp.srec
  ILINK.IlinkOutputFile: r01an5648-rl78g23-cmp.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: src\smc_gen\Config_COMP0; src\smc_gen\Config_COMP1; src\smc_gen\Config_DAC0; src\smc_gen\Config_PORT; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config
  group (top)
    ./: main.c r01an5648-rl78g23-cmp.ipcf
  group Renesas_SC/smc_gen/Config_COMP0
    src/smc_gen/Config_COMP0/: Config_COMP0.c Config_COMP0.h Config_COMP0_user.c
  group Renesas_SC/smc_gen/Config_COMP1
    src/smc_gen/Config_COMP1/: Config_COMP1.c Config_COMP1.h Config_COMP1_user.c
  group Renesas_SC/smc_gen/Config_DAC0
    src/smc_gen/Config_DAC0/: Config_DAC0.c Config_DAC0.h Config_DAC0_user.c
  group Renesas_SC/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_comp.h r_cg_comp_common.c r_cg_comp_common.h r_cg_da.h r_cg_da_common.c r_cg_da_common.h r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_port.h r_cg_systeminit.c r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_g23
    src/smc_gen/r_bsp/board/generic_rl78_g23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s r_bsp_common.c r_bsp_common.h r_bsp_rl78_compiler.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23
    src/smc_gen/r_bsp/mcu/rl78_g23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl/: intrinsics.h ior7f100g.h ior7f100g_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h
