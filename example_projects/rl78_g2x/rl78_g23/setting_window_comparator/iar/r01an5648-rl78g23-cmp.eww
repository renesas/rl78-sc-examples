<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an5648-rl78g23-cmp.ewp</path>
    </project>
    <batchBuild />
</workspace>
