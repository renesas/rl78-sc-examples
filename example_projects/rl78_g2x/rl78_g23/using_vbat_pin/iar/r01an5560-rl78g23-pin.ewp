# IAR project r01an5560-rl78g23-pin.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F100GLG RL78 - R7F100GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\smc_gen\Config_IICA0; src\smc_gen\Config_LVD0; src\smc_gen\Config_RTC; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\LCM_driver
  ARL78.AsmIncludePath: src\smc_gen\r_config
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: r01an5560-rl78g23-pin.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: src\smc_gen\Config_IICA0; src\smc_gen\Config_LVD0; src\smc_gen\Config_RTC; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config
  group (top)
    ./: main.c r01an5560-rl78g23-pin.ipcf
  group src/LCM_driver
    src/LCM_driver/: LCM_driver.c LCM_driver.h LCM_driver_config.h
  group src/smc_gen/Config_IICA0
    src/smc_gen/Config_IICA0/: Config_IICA0.c Config_IICA0.h Config_IICA0_user.c
  group src/smc_gen/Config_LVD0
    src/smc_gen/Config_LVD0/: Config_LVD0.c Config_LVD0.h Config_LVD0_user.c
  group src/smc_gen/Config_RTC
    src/smc_gen/Config_RTC/: Config_RTC.c Config_RTC.h Config_RTC_user.c
  group src/smc_gen/general
    src/smc_gen/general/: r_cg_iica.h r_cg_iica_common.c r_cg_iica_common.h r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_rtc.h r_cg_rtc_common.c r_cg_rtc_common.h r_cg_systeminit.c r_cg_userdefine.h r_smc_entry.h
  group src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group src/smc_gen/r_bsp/board/generic_rl78_g23
    src/smc_gen/r_bsp/board/generic_rl78_g23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_config_reference_ccrl.inc r_bsp_config_reference_iccrl.inc r_bsp_config_reference_llvm.inc r_bsp_init.c
  group src/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0120-rl78-bsp.pdf
  group src/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0120-rl78-bsp.pdf
  group src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s fsp_common_api.h r_bsp_common.c r_bsp_common.h r_bsp_rl78_compiler.h r_fsp_error.h r_rtos.h
  group src/smc_gen/r_bsp/mcu/rl78_g23
    src/smc_gen/r_bsp/mcu/rl78_g23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl/: intrinsics.h iodefine.h iodefine_ext.h
  group src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config.inc
