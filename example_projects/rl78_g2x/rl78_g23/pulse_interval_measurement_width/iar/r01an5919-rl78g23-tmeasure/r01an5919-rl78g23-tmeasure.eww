<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an5919-rl78g23-tmeasure.ewp</path>
    </project>
    <batchBuild />
</workspace>
