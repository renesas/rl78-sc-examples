<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an5874-rl78g23_tau.ewp</path>
    </project>
    <batchBuild />
</workspace>
