<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an5631-rl78g23-adc.ewp</path>
    </project>
    <batchBuild/>
</workspace>