# IAR project r01an5598_rl78g23_uarta.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R7F100GLG RL78 - R7F100GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  General.GenHugeHeapSize: 0
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: $PROJ_DIR$; src\smc_gen\Config_PORT; src\smc_gen\Config_UARTA0; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config
  ILINK.IlinkOutputFile: r01an5598_rl78g23_uarta.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: main.c
  group src/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group src/smc_gen/Config_UARTA0
    src/smc_gen/Config_UARTA0/: Config_UARTA0.c Config_UARTA0.h Config_UARTA0_user.c
  group src/smc_gen/general
    src/smc_gen/general/: r_cg_macrodriver.h r_cg_port.h r_cg_systeminit.c r_cg_uarta.h r_cg_uarta_common.c r_cg_uarta_common.h r_cg_userdefine.h r_smc_entry.h
  group src/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h
  group src/smc_gen/r_bsp/board/generic_rl78_g23
    src/smc_gen/r_bsp/board/generic_rl78_g23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_init.c
  group src/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s r_bsp_common.c r_bsp_common.h r_bsp_rl78_compiler.h
  group src/smc_gen/r_bsp/mcu/rl78_g23
    src/smc_gen/r_bsp/mcu/rl78_g23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl/: intrinsics.h ior7f100g.h ior7f100g_ext.h
  group src/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h
