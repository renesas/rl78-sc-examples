<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\r01an5598_rl78g23_uarta.ewp</path>
    </project>
    <batchBuild />
</workspace>
