# IAR project r01an5556.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F100GLG RL78 - R7F100GLG
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\Config_INTC; src\smc_gen\Config_ITL000_ITL001; src\smc_gen\Config_TAU0_0
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: r01an5556.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: main.c r01an5556.ipcf
  group Renesas_SC/smc_gen/Config_INTC
    src/smc_gen/Config_INTC/: Config_INTC.c Config_INTC.h Config_INTC_user.c
  group Renesas_SC/smc_gen/Config_ITL000_ITL001
    src/smc_gen/Config_ITL000_ITL001/: Config_ITL000_ITL001.c Config_ITL000_ITL001.h Config_ITL000_ITL001_user.c
  group Renesas_SC/smc_gen/Config_TAU0_0
    src/smc_gen/Config_TAU0_0/: Config_TAU0_0.c Config_TAU0_0.h Config_TAU0_0_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_intc.h r_cg_itl.h r_cg_itl_common.c r_cg_itl_common.h r_cg_itl_common_user.c r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_systeminit.c r_cg_tau.h r_cg_tau_common.c r_cg_tau_common.h r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_g23
    src/smc_gen/r_bsp/board/generic_rl78_g23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0100-rl78.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s r_bsp_common.c r_bsp_common.h r_bsp_rl78_compiler.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23
    src/smc_gen/r_bsp/mcu/rl78_g23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_g23/register_access/iccrl/: intrinsics.h ior7f100g.h ior7f100g_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h
