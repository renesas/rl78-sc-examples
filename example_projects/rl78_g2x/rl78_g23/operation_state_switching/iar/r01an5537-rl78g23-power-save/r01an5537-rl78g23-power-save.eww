<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an5537-rl78g23-power-save.ewp</path>
    </project>
    <batchBuild/>
</workspace>