<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an5625-rl78g23-port.ewp</path>
    </project>
    <batchBuild/>
</workspace>