<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an6646_rl78g23_uarta.ewp</path>
    </project>
    <batchBuild/>
</workspace>