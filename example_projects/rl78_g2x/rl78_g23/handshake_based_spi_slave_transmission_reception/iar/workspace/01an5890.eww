<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\01an5890.ewp</path>
    </project>
    <batchBuild />
</workspace>
