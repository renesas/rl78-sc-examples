<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\bank2_temp.ewp</path>
    </project>
    <batchBuild/>
</workspace>