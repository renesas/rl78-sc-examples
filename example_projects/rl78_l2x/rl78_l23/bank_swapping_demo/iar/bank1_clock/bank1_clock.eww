<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\bank1_clock.ewp</path>
    </project>
    <batchBuild/>
</workspace>