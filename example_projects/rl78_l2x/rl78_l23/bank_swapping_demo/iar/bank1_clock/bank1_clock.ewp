# IAR project bank1_clock.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F100LPL RL78 - R7F100LPL
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 0x900
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCDefines: QE_TOUCH_CONFIGURATION
  ICCRL78.CCIncludePath2: src\include\rfd; src\include; src\sample\RL78_L23\BP_SWAP\IAR\include; src\sample\common\include; qe_gen; src; src\smc_gen\Config_INTC; src\smc_gen\Config_LCD; src\smc_gen\Config_PORT; src\smc_gen\Config_RTC; src\smc_gen\Config_TAU0_1; src\smc_gen\Config_TAU0_2; src\smc_gen\Config_TAU0_3; src\smc_gen\Config_TAU0_4; src\smc_gen\Config_TAU0_5; src\smc_gen\general; src\smc_gen\rm_touch; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_ctsu; src\smc_gen\r_pincfg; HardwareDebug\src\smc_gen\r_ctsu
  ARL78.AsmIncludePath: src\smc_gen\r_config
  OBJCOPY.OOCOutputFile: bank1_clock.hex
  ILINK.IlinkOutputFile: bank1_clock.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkIcfFile: src\sample\RL78_L23\BP_SWAP\IAR\source\sample_linker_file_BP_SWAP.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  General.GenStackSize: 128
  ICCRL78.CCDefines: NDEBUG
  ICCRL78.CCIncludePath2: src\smc_gen\Config_INTC; src\smc_gen\Config_LCD; src\smc_gen\Config_PORT; src\smc_gen\Config_RTC; src\smc_gen\Config_TAU0_1; src\smc_gen\Config_TAU0_2; src\smc_gen\Config_TAU0_3; src\smc_gen\Config_TAU0_4; src\smc_gen\Config_TAU0_5; src\smc_gen\general; src\smc_gen\rm_touch; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_ctsu; src\smc_gen\r_pincfg; HardwareDebug\src\smc_gen\r_ctsu
  OBJCOPY.OOCOutputFile: templproj.srec
  group (top)
    ./: buildinfo.ipcf
  group QE-Touch
    QE-Touch/: bank1_clock.tifcfg
  group qe_gen
    qe_gen/: qe_touch_config.c qe_touch_config.h qe_touch_define.h qe_touch_sample.c
  group Renesas_SC/smc_gen/Config_INTC
    src/smc_gen/Config_INTC/: Config_INTC.c Config_INTC.h Config_INTC_user.c
  group Renesas_SC/smc_gen/Config_LCD
    src/smc_gen/Config_LCD/: Config_LCD.c Config_LCD.h Config_LCD_user.c
  group Renesas_SC/smc_gen/Config_PORT
    src/smc_gen/Config_PORT/: Config_PORT.c Config_PORT.h Config_PORT_user.c
  group Renesas_SC/smc_gen/Config_RTC
    src/smc_gen/Config_RTC/: Config_RTC.c Config_RTC.h Config_RTC_user.c
  group Renesas_SC/smc_gen/Config_TAU0_1
    src/smc_gen/Config_TAU0_1/: Config_TAU0_1.c Config_TAU0_1.h Config_TAU0_1_user.c
  group Renesas_SC/smc_gen/Config_TAU0_2
    src/smc_gen/Config_TAU0_2/: Config_TAU0_2.c Config_TAU0_2.h Config_TAU0_2_user.c
  group Renesas_SC/smc_gen/Config_TAU0_3
    src/smc_gen/Config_TAU0_3/: Config_TAU0_3.c Config_TAU0_3.h Config_TAU0_3_user.c
  group Renesas_SC/smc_gen/Config_TAU0_4
    src/smc_gen/Config_TAU0_4/: Config_TAU0_4.c Config_TAU0_4.h Config_TAU0_4_user.c
  group Renesas_SC/smc_gen/Config_TAU0_5
    src/smc_gen/Config_TAU0_5/: Config_TAU0_5.c Config_TAU0_5.h Config_TAU0_5_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_intc.h r_cg_lcd.h r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_port.h r_cg_rtc.h r_cg_rtc_common.c r_cg_rtc_common.h r_cg_systeminit.c r_cg_tau.h r_cg_tau_common.c r_cg_tau_common.h r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_l23
    src/smc_gen/r_bsp/board/generic_rl78_l23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_config_reference_ccrl.inc r_bsp_config_reference_iccrl.inc r_bsp_config_reference_llvm.inc r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0191-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0191-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s fsp_common_api.h r_bsp_common.c r_bsp_common.h r_bsp_common_iar.asm r_bsp_rl78_compiler.h r_fsp_error.h r_rtos.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_l23
    src/smc_gen/r_bsp/mcu/rl78_l23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_l23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_l23/register_access/iccrl/: intrinsics.h iodefine.h iodefine_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config.inc r_ctsu_config.h rm_touch_config.h
  group Renesas_SC/smc_gen/r_ctsu
    src/smc_gen/r_ctsu/: r_ctsu.c r_ctsu.h r_ctsu_api.h r_ctsu_sms_asm.smsasm r_ctsu_sms_asm_mutual.smsasm
  group Renesas_SC/smc_gen/r_ctsu/doc/en
    src/smc_gen/r_ctsu/doc/en/: r11an0484ej0220-rl78.pdf
  group Renesas_SC/smc_gen/r_ctsu/doc/jp
    src/smc_gen/r_ctsu/doc/jp/: r11an0484jj0220-rl78.pdf
  group Renesas_SC/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h r_ctsu_pinset.c r_ctsu_pinset.h
  group Renesas_SC/smc_gen/rm_touch
    src/smc_gen/rm_touch/: rm_touch.c rm_touch.h rm_touch_api.h
  group Renesas_SC/smc_gen/rm_touch/doc/en
    src/smc_gen/rm_touch/doc/en/: r11an0485ej0220-rl78.pdf
  group Renesas_SC/smc_gen/rm_touch/doc/jp
    src/smc_gen/rm_touch/doc/jp/: r11an0485jj0220-rl78.pdf
  group src
    src/: bank1_clock.c clock.c clock.h lcd_segdata.c
  group src/include
    src/include/: r_rfd_code_flash_api.h r_rfd_code_flash_control_api.h r_rfd_code_flash_userown.h r_rfd_common_api.h r_rfd_common_control_api.h r_rfd_common_get_api.h r_rfd_common_userown.h r_rfd_data_flash_api.h r_rfd_data_flash_control_api.h r_rfd_data_flash_userown.h r_rfd_extra_area_api.h r_rfd_extra_area_control_api.h r_rfd_extra_area_security_api.h r_rfd_extra_area_userown.h r_rfd_extra_extension_api.h
  group src/include/rfd
    src/include/rfd/: r_rfd.h r_rfd_compiler.h r_rfd_device.h r_rfd_memmap.h r_rfd_types.h r_typedefs.h
  group src/sample/common/include
    src/sample/common/include/: sample_control_bank_programming.h sample_control_bank_swap.h sample_control_code_flash.h sample_control_data_flash.h sample_control_extra_fsw.h sample_defines.h sample_memmap.h sample_types.h
  group src/sample/common/source/bank_swap
    src/sample/common/source/bank_swap/: sample_control_bank_programming.c sample_control_bank_swap.c
  group src/sample/common/source/dataflash
    src/sample/common/source/dataflash/: sample_control_data_flash.c
  group src/sample/RL78_L23/BP_SWAP/IAR/include
    src/sample/RL78_L23/BP_SWAP/IAR/include/: sample_bank_swapped_code.h sample_config.h
  group src/sample/RL78_L23/BP_SWAP/IAR/source
    src/sample/RL78_L23/BP_SWAP/IAR/source/: sample_bank_swapped_code.c sample_linker_file_BP_SWAP.icf
  group src/source/codeflash
    src/source/codeflash/: r_rfd_code_flash_api.c r_rfd_code_flash_control_api.c
  group src/source/common
    src/source/common/: r_rfd_common_api.c r_rfd_common_control_api.c r_rfd_common_get_api.c
  group src/source/dataflash
    src/source/dataflash/: r_rfd_data_flash_api.c r_rfd_data_flash_control_api.c
  group src/source/extraarea
    src/source/extraarea/: r_rfd_extra_area_api.c r_rfd_extra_area_control_api.c r_rfd_extra_area_security_api.c r_rfd_extra_extension_api.c
  group src/userown
    src/userown/: r_rfd_code_flash_userown.c r_rfd_common_userown.c r_rfd_data_flash_userown.c r_rfd_extra_area_userown.c
