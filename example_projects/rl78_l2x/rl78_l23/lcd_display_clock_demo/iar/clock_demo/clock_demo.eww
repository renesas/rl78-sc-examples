<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\clock_demo.ewp</path>
    </project>
    <batchBuild/>
</workspace>