<?xml version="1.0" encoding="UTF-8" standalone="no"?><workspace>
    <project>
        <path>$WS_DIR$\r01an7834-rl78l23-lcd.ewp</path>
    </project>
    <batchBuild/>
</workspace>