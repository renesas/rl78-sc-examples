# IAR project r01an7834-rl78l23-lcd.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenHugeHeapSize: 0
  General.GenDeviceSelect: R7F100LPL RL78 - R7F100LPL
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 128
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: src\smc_gen\Config_INTC; src\smc_gen\Config_IT00; src\smc_gen\Config_IT01; src\smc_gen\Config_LCD; src\smc_gen\Config_RTC; src\smc_gen\general; src\smc_gen\r_bsp; src\smc_gen\r_config; src\smc_gen\r_pincfg
  ARL78.AsmIncludePath: src\smc_gen\r_config
  OBJCOPY.OOCOutputFile: templproj.srec
  ILINK.IlinkOutputFile: r01an7834-rl78l23-lcd.out
  ILINK.IlinkConfigDefines: __RESERVE_OCD_ROM=1; __RESERVE_OCD_TRACE_RAM=0; __RESERVE_HOTPLUGIN_RAM=0
  ILINK.IlinkStackSize: 1
  ILINK.IlinkNearHeapSize: 1
  ILINK.IlinkFarHeapSize: 1
  ILINK.IlinkHugeHeapSize: 1
configuration Release (RL78)
  as the first configuration, except:
  General.GenDeviceSelect: UnspecifiedRL78_2 RL78 core S3 - Unspecified
  ICCRL78.CCDefines: NDEBUG
  group (top)
    ./: buildinfo.ipcf main.c
  group Renesas_SC/smc_gen/Config_INTC
    src/smc_gen/Config_INTC/: Config_INTC.c Config_INTC.h Config_INTC_user.c
  group Renesas_SC/smc_gen/Config_IT00
    src/smc_gen/Config_IT00/: Config_IT00.c Config_IT00.h Config_IT00_user.c
  group Renesas_SC/smc_gen/Config_IT01
    src/smc_gen/Config_IT01/: Config_IT01.c Config_IT01.h Config_IT01_user.c
  group Renesas_SC/smc_gen/Config_LCD
    src/smc_gen/Config_LCD/: Config_LCD.c Config_LCD.h Config_LCD_user.c
  group Renesas_SC/smc_gen/Config_RTC
    src/smc_gen/Config_RTC/: Config_RTC.c Config_RTC.h Config_RTC_user.c
  group Renesas_SC/smc_gen/general
    src/smc_gen/general/: r_cg_intc.h r_cg_it8bit.h r_cg_it8bit_common.c r_cg_it8bit_common.h r_cg_lcd.h r_cg_lvd.h r_cg_lvd_common.c r_cg_lvd_common.h r_cg_lvd_common_user.c r_cg_macrodriver.h r_cg_rtc.h r_cg_rtc_common.c r_cg_rtc_common.h r_cg_systeminit.c r_cg_userdefine.h r_smc_entry.h
  group Renesas_SC/smc_gen/r_bsp
    src/smc_gen/r_bsp/: platform.h readme.txt
  group Renesas_SC/smc_gen/r_bsp/board/generic_rl78_l23
    src/smc_gen/r_bsp/board/generic_rl78_l23/: hdwinit.c hdwinit.h r_bsp.h r_bsp_config_reference.h r_bsp_config_reference_ccrl.inc r_bsp_config_reference_iccrl.inc r_bsp_config_reference_llvm.inc r_bsp_init.c
  group Renesas_SC/smc_gen/r_bsp/doc/en
    src/smc_gen/r_bsp/doc/en/: r01an5522ej0190-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/doc/ja
    src/smc_gen/r_bsp/doc/ja/: r01an5522jj0190-rl78-bsp.pdf
  group Renesas_SC/smc_gen/r_bsp/mcu/all
    src/smc_gen/r_bsp/mcu/all/: cstartup.s fsp_common_api.h r_bsp_common.c r_bsp_common.h r_bsp_common_iar.asm r_bsp_rl78_compiler.h r_fsp_error.h r_rtos.h
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_l23
    src/smc_gen/r_bsp/mcu/rl78_l23/: mcu_clocks.c mcu_clocks.h mcu_info.h vecttbl.c
  group Renesas_SC/smc_gen/r_bsp/mcu/rl78_l23/register_access/iccrl
    src/smc_gen/r_bsp/mcu/rl78_l23/register_access/iccrl/: intrinsics.h iodefine.h iodefine_ext.h
  group Renesas_SC/smc_gen/r_config
    src/smc_gen/r_config/: r_bsp_config.h r_bsp_config.inc
  group Renesas_SC/smc_gen/r_pincfg
    src/smc_gen/r_pincfg/: Pin.c Pin.h
